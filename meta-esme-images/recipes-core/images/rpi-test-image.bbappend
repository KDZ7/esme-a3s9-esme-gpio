IMAGE_INSTALL += "packagegroup-esme-utils"
