inherit externalsrc
EXTERNALSRC = "/home/kdz7/w/src/gpio-toggle"
EXTERNALSRC_BUILD = "/home/kdz7/w/src/gpio-toggle"

# initial_rev .: 1d67e5cc3eabf008e38a81d552c946ac2671e0e6
